# Dummy class to satisfy meta-python recipes that inherit python_pdm on walnascar.
# We do not build those recipes; this prevents parse-time failures.


